# Keil uVision project LPC1113_GCC_VSCode_Uart.uvprojx, settings and files
target Target 1 (ARM-GNU)
  device: LPC1113FBD48/301 NXP
  pack: Keil.LPC1100_DFP.1.4.0
  cpu: IRAM(0x10000000,0x2000) IROM(0x00000000,0x6000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: LPC1113_GCC_VSCode_Uart
